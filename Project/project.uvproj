# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\Platform;..\User;..\APP;..\BSP;..\uCOS-III\Cfg;..\uCOS-III\Ports;..\uCOS-III\Source;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./: startup_stm32f10x_hd.s
  group STM32F1Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Platform
    ../Platform/: stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/: bsp.c
  group APP
    ../APP/: app.c
  group uC/Source
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Ports
    ../uCOS-III/Ports/: os_cpu_c.c os_cpu_a.asm
  group uC/LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/CPU
    ../uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uC/Cfg
    ../uCOS-III/Cfg/: os_app_hooks.c
